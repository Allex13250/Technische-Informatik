# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431KB ST STM32G431KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: C:\Users\Lenovo\Desktop\HEILBRONN\TECHNISCHE INFORMATIK\system_stm32g4xx.c; C:\Users\Lenovo\Desktop\HEILBRONN\TECHNISCHE INFORMATIK\startup_stm32g431xx.s; C:\Users\Lenovo\Desktop\HEILBRONN\TECHNISCHE INFORMATIK\Port_interrupt.c
  ICCARM.CCIncludePath2: C:\Users\Lenovo\Desktop\HEILBRONN\TECHNISCHE INFORMATIK\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
